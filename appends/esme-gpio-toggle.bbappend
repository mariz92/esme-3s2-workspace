inherit externalsrc
EXTERNALSRC = "/home/mariz/w/src/esme-3s2-gpio-toggle"
EXTERNALSRC_BUILD = "/home/mariz/w/src/esme-3s2-gpio-toggle"

# initial_rev .: 9975833c73be84f76bf974d8865db093edff94fc
